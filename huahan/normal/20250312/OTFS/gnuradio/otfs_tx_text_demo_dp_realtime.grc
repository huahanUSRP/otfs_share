options:
  parameters:
    generate_options: qt_gui
    id: fh_scma
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: file_index
  id: variable
  parameters:
    value: 0 if samp_rate == 250 else (1 if samp_rate == 5000else (2 if samp_rate == 1000 else 3))
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: '"bandwidth"'
    label0: '"250kHz"'
    label1: '"500kHz"'
    label2: '"1MHz"'
    label3: '"2MHz"'
    num_opts: '4'
    option0: '250'
    option1: '500'
    option2: '1000'
    option3: '2000'
    type: int
    value: '1000'
    widget: radio_buttons
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: samp_rate
    type: int
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../tx_fifo
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '10000'
    type: int
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '8'
    port: '34567'
    send_eof: 'False'
    type: int
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"tx baseband data"'
    plotconst: 'False'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 5.9e9
    clock_source0: gpsdo
    gain0: '30'
    samp_rate: samp_rate*1000
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', qtgui_sink_x_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle2_0, '0', network_udp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
