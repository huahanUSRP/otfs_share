options:
  parameters:
    generate_options: qt_gui
    id: fh_scma
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate_0
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../tx_otfs_USRP_Tx_text.sc
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_0
    fc: '0'
    fftsize: '1024'
    plotconst: 'False'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 2.0e9
    gain0: '15'
    samp_rate: samp_rate_0
    sync: none
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_sink_x_0, '0']
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_file_source_0, '0', qtgui_sink_x_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
