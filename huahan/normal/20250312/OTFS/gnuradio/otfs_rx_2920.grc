options:
  parameters:
    generate_options: qt_gui
    id: hp_scma_rx_streaming
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: ../rx_fifo_file
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    alias: “Rx”
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: RX
    showrf: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 2.0e9
    clock_source0: internal
    gain0: '10'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_sink_1, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
