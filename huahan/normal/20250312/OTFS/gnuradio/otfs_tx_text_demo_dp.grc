options:
  parameters:
    generate_options: qt_gui
    id: fh_scma
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: file_index
  id: variable
  parameters:
    value: 0 if samp_rate == 250000 else (1 if samp_rate == 500000 else (2 if samp_rate == 1000000 else 3))
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: '"bandwidth"'
    label0: '"250kHz"'
    label1: '"500kHz"'
    label2: '"1MHz"'
    label3: '"2MHz"'
    num_opts: '4'
    option0: '250000'
    option1: '500000'
    option2: '1000000'
    option3: '2000000'
    type: int
    value: '2000000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../tx_otfs_USRP_Tx_text_250k_d.sc
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: ../tx_otfs_USRP_Tx_text_2m_d.sc
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: ../tx_otfs_USRP_Tx_text_500k_d.sc
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    file: ../tx_otfs_USRP_Tx_text_1m_d.sc
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: file_index
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    plotconst: 'False'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 5.9e9
    clock_source0: gpsdo
    gain0: '30'
    samp_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_sink_x_0, '0']
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_file_source_0, '0', blocks_selector_0, '0']
- [blocks_file_source_0_0, '0', blocks_selector_0, '3']
- [blocks_file_source_0_1, '0', blocks_selector_0, '1']
- [blocks_file_source_0_2, '0', blocks_selector_0, '2']
- [blocks_selector_0, '0', qtgui_sink_x_0, '0']
- [blocks_selector_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
